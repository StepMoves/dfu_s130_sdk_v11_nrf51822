# Keil uVision project air_filter_boot.uvprojx, settings and files
target air_filter_boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: air_filter_boot +hex
  AfterMake: fromelf.exe --bin --output .\Objects\air_filter_boot.bin  .\Objects\air_filter_boot.axf
  c flags: Optim=4 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S130 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\RTE\bsp;..\RTE\Device\nRF51822_xxAC;..\RTE\nRF_BLE\nRF51822_xxAC;..\RTE\nRF_Drivers\nRF51822_xxAC;..\RTE\nRF_Libraries\nRF51822_xxAC;..\RTE\nRF_SoftDevice\nRF51822_xxAC;..\source
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002000 size 0x1f80
  memory RVCT10: RAM 0x20003f80 size 0x80
  group application
    ../source/: dfu_ble_svc.c main.c
  group board_support
    ../RTE/bsp/: air_filter_board.h boards.h
  group cmsis
    ../RTE/Device/nRF51822_xxAC/: arm_const_structs.h arm_math.h cmsis_armcc.h compiler_abstraction.h core_cm0.h core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group device
    ../RTE/Device/nRF51822_xxAC/: system_nrf51.c arm_startup_nrf51.s
  group nrf_ble
    ../RTE/nRF_BLE/nRF51822_xxAC/: ble_advdata.c ble_conn_params.c ble_dfu.c ble_srv_common.c
  group nrf_drivers
    ../RTE/nRF_Drivers/nRF51822_xxAC/: nrf_delay.c nrf_drv_common.c pstorage_raw.c
  group nrf_libraries
    ../RTE/nRF_Libraries/nRF51822_xxAC/: app_error.c app_scheduler.c app_timer.c app_timer_appsh.c bootloader.c bootloader_settings.c bootloader_util.c crc16.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c hci_mem_pool.c
  group nrf_softdevice
    ../RTE/nRF_SoftDevice/nRF51822_xxAC/: softdevice_handler.c softdevice_handler_appsh.c
